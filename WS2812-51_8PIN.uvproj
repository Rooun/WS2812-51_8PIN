# Keil uVision project WS2812-51_8PIN.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: WS2812-51_8PIN +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: STARTUP.A51 main.c Delay.c ws2812.c Flash.c
